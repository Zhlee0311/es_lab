# Keil uVision project EID-V2.uvprojx, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210B-EVAL
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Core\CM3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../src/: main.c dma.c EXTI.c systick.c UART.c IIC-lib.c Timer.c SPI.c lcd.c serial.c
  group StdPeriph_Driver
    ../src/: stm32f10x_it.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_i2c.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_dma.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_sdio.c stm32f10x_wwdg.c
  group RVMDK
    ../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c
  group Inc
    ../inc/: DigitalTube.h dma.h EXTI.h FONT.H iic.h lcd.h Register_config.h stm32f10x_it.h sys.h wdg.h stm32f10x_conf.h main.h systick.h UART.h serial.h
target STM3210E-EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E-EVAL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
